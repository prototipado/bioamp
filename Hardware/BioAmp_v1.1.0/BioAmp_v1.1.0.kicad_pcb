# Repository prototipado/bioamp

File README.md:

# BioAmp Project

[Laboratorio de Prototipado Electronico y 3D](http://ingenieria.uner.edu.ar/grupos/prototipado) - Laboratorio de Ingenierı́a en Rehabilitación e Investigaciones Neuromusculares y Sensoriales (LIRINS) - [FIUNER](http://ingenieria.uner.edu.ar)

*Copyright 2017 - Laboratorio de Prototipado Electronico y 3D - FIUNER*

Redistribution and use in source and binary forms, with or without modification, are permitted provided that the following conditions are met:

1. Redistributions of source code must retain the above copyright notice, this list of conditions and the following disclaimer.
2. Redistributions in binary form must reproduce the above copyright notice, this list of conditions and the following disclaimer in the documentation and/or other materials provided with the distribution.
3. Neither the name of the copyright holder nor the names of its contributors may be used to endorse or promote products derived from this design without specific prior written permission.

THIS DESING IS PROVIDED BY THE COPYRIGHT HOLDERS AND CONTRIBUTORS "AS IS" AND ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED TO, THE IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR PURPOSE ARE DISCLAIMED. IN NO EVENT SHALL THE COPYRIGHT HOLDER OR CONTRIBUTORS BE LIABLE FOR ANY DIRECT, INDIRECT, INCIDENTAL, SPECIAL, EXEMPLARY, OR CONSEQUENTIAL DAMAGES (INCLUDING, BUT NOT LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS OR SERVICES; LOSS OF USE, DATA, OR PROFITS; OR BUSINESS INTERRUPTION) HOWEVER CAUSED AND ON ANY THEORY OF LIABILITY, WHETHER IN CONTRACT, STRICT LIABILITY, OR TORT (INCLUDING NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY OUT OF THE USE OF THIS DESIGN, EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGE.

### Initial Authors
- Juan Ignacio Cerrudo (juanicerrudo@gmail.com) - Developer
- Agustin Solano (asolano@gmail.com) - Developer
- Eduardo Filomena (efilomena@ingenieria.uner.edu.ar) - Requirements Definition
- Juan Manuel Reta (jmreta@ingenieria.uner.edu.ar ) - Project Manager

### Colaborators
- Albano Peñalva (albanopenialva@gmail.com) - Developer
- Christian Mista (cmista@ingenieria.uner.edu.ar) - Developer

### About project
BioAmp is an opensource project of a multichannel biopotential adquisition system for EEG, EMG, EOG and EOG signals.

The device has 8 programmable channels - 2000 Hz maximun sampling frequency, allowing the acquisition of biopotentials.

### Features

- Resolution: 17 - 19 bits depending on settings (gain and sampling frequency).
- Channels: 8 differential channels / 8 monopolar channels.
- Input Impedance: ≥ 500 M Ω
- Dimentions: 153x114x34mm

### 📫 Contact us
Laboratorio de Prototipado Electronico y 3D - FIUNER (http://ingenieria.uner.edu.ar/grupos/prototipado)

Laboratorio de Ingenierı́a en Rehabilitación e Investigaciones Neuromusculares y Sensoriales (LIRINS)

## KiCad design Hardware/BioAmp_v1.1.0/BioAmp_v1.1.0.kicad_pcb

Parts:
CN1, CN2, CN3: CKCL44X7R1H; Cap_Array_4
J1, J2, J3, J4, J5, J6, J7, J8, J9: Jack_Touch-Proof; Jack_TouchProof_1.5mm
P1: CONN_01X10; Pin_Header_Straight_1x10
RN1, RN2, RN3: CAY16-F4_R-ARRAY; r_cay16-4
U1, U2, U3: TPD4E1B06; TSOP-6_2x1.25mm_Pitch0.65mm

Connections:
/Analog Front End/RL_DRV: P1.1; also elsewhere on the board
/Entradas Analogicas/E1+: J8.1, RN2.4, U2.5 (IO4)
/Entradas Analogicas/E1-: J7.1, RN2.3, U2.4 (IO3)
/Entradas Analogicas/E2+: J6.1, RN2.2, U2.2 (IO2)
/Entradas Analogicas/E2-: J5.1, RN2.1, U2.1 (IO1)
/Entradas Analogicas/E7+: J4.1, RN1.4, U1.5 (IO4)
/Entradas Analogicas/E7-: J3.1, RN1.3, U1.4 (IO3)
/Entradas Analogicas/E8+: J2.1, RN1.2, U1.2 (IO2)
/Entradas Analogicas/E8-: J1.1, RN1.1, U1.1 (IO1)
/Entradas Analogicas/IN1+: CN2.1, RN2.5; also elsewhere on the board
/Entradas Analogicas/IN1-: CN2.2, RN2.6; also elsewhere on the board
/Entradas Analogicas/IN2+: CN2.3, RN2.7; also elsewhere on the board
/Entradas Analogicas/IN2-: CN2.4, RN2.8; also elsewhere on the board
/Entradas Analogicas/IN3+: P1.2; also elsewhere on the board
/Entradas Analogicas/IN3-: P1.3; also elsewhere on the board
/Entradas Analogicas/IN4+: P1.4; also elsewhere on the board
/Entradas Analogicas/IN4-: P1.5; also elsewhere on the board
/Entradas Analogicas/IN5+: P1.6; also elsewhere on the board
/Entradas Analogicas/IN5-: P1.7; also elsewhere on the board
/Entradas Analogicas/IN6+: P1.8; also elsewhere on the board
/Entradas Analogicas/IN6-: P1.9; also elsewhere on the board
/Entradas Analogicas/IN7+: CN1.1, RN1.5; also elsewhere on the board
/Entradas Analogicas/IN7-: CN1.2, RN1.6; also elsewhere on the board
/Entradas Analogicas/IN8+: CN1.3, RN1.7; also elsewhere on the board
/Entradas Analogicas/IN8-: CN1.4, RN1.8; also elsewhere on the board
/Entradas Analogicas/IN_SRB: CN3.1, RN3.8; also elsewhere on the board
/Entradas Analogicas/SRB: J9.1, RN3.1, U3.1 (IO1)
GNDA: CN1.5, CN1.6, CN1.7, CN1.8, CN2.5, CN2.6, CN2.7, CN2.8, CN3.8, J1.2 (Shield), J2.2 (Shield), J3.2 (Shield), J4.2 (Shield), J5.2 (Shield), J6.2 (Shield), J7.2 (Shield), J8.2 (Shield), J9.2 (Shield), P1.10, U1.3 (GND), U2.3 (GND), U3.3 (GND); also elsewhere on the board

Notes on the sheet:
SRB: Patient stimulus, reference, and bias signal. RLD: Driver de Pierna Derecha.
2.2k
1nF

Parts:
C1, C2: 18pF; C_0603
C3, C5, C7, C9: 10nF; C_0603
C4, C6, C8, C10: 100nF; C_0603
D1: Led_bicolor
P2: JTAG; Pin_Header_Straight_1x08
Q1, Q2: Q_NMOS_SGD-RESCUE-Biopotenciales_LIRINS_v2
R1, R4, R5: 1k; R_0603
R2, R7, R11, R12: 10k; R_0603
R3: 12k; R_0603
R6, R10: 330k; R_0603
R8, R9: 560; R_0603
S1: SW_PUSH; SW_Tactile_SPST_Angled
U4: LPC1769FBD100; LQFP-100_14x14mm_Pitch0.5mm
Y1: 12MHz; XTAL_AM3B

Connections:
5V_ISO: D1.2 (A); also elsewhere on the board
/Analog Front End/DRDY/: U4.51 (P2[12]/~EINT2~/I2STX_WS); also elsewhere on the board
/Analog Front End/M/S: R5.2, U4.43 (P1[27]/CLKOUT/~USB_OVRCR~/CAP0[1]); also elsewhere on the board
/Analog Front End/MISO: U4.61 (P0[17]/CTS1/MISO0/MISO); also elsewhere on the board
/Analog Front End/MOSI: U4.60 (P0[18]/DCD1/MOSI0/MOSI); also elsewhere on the board
/Analog Front End/RESET/: U4.65 (P2[8]/TD2/TXD2); also elsewhere on the board
/Analog Front End/START: U4.64 (P2[9]/USB_CONNECT/RXD2); also elsewhere on the board
/Comunicacion USB/I_RX0: U4.99 (P0[3]/RXD0/AD0[6]); also elsewhere on the board
/Comunicacion USB/I_TX0: U4.98 (P0[2]/TXD0/AD0[7]); also elsewhere on the board
/Interfaz Interconectividad/CS1: U4.63 (P0[16]/RXD1/SSEL0/SSEL); also elsewhere on the board
/Interfaz Interconectividad/CS2: U4.44 (P1[28]/MCOA2/PCAP1[0]/MAT0[0]); also elsewhere on the board
/Interfaz Interconectividad/CS3: U4.75 (P2[0]/PWM1[1]/TXD1); also elsewhere on the board
/Interfaz Interconectividad/SCL: R1.2, U4.24 (P0[28]/SCL0/USB_SCL); also elsewhere on the board
/Interfaz Interconectividad/SDA: R4.2, U4.25 (P0[27]/SDA0/USB_SDA); also elsewhere on the board
/Microcontrolador/ISP: R12.2, S1.1, U4.53 (P2[10]/~EINT0~/NMI)
/Microcontrolador/LED_R: R6.1, R7.1, U4.95 (P1[0]/ENET_TXD0)
/Microcontrolador/LED_V: R10.1, R11.1, U4.94 (P1[1]/ENET_TDX1)
/Microcontrolador/RST/: P2.3, R3.1, U4.17 (~RESET~)
/Microcontrolador/SCK: U4.62 (P0[15]/TXD1/SCK0/SCK); also elsewhere on the board
/Microcontrolador/TCK: P2.6, U4.5 (TCK/SWDCLK)
/Microcontrolador/TDI: P2.4, U4.2 (TDI)
/Microcontrolador/TDO: P2.5, U4.1 (TDO/SWO)
/Microcontrolador/TMS: P2.7, U4.3 (TMS/SWDIO)
D_VCC: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, R1.1, R2.2, R3.2, R4.1, R5.1, R12.1, U4.10 (VDDA), U4.12 (VREFP), U4.19 (VBAT), U4.28 (VDD(3V3)), U4.42 (VDD(REG)(3V3)), U4.54 (VDD(3V3)), U4.71 (VDD(3V3)), U4.84 (VDD(REG)(3V3)), U4.96 (VDD(3V3)); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, P2.1, Q1.2 (S), Q2.2 (S), R6.2, R10.2, S1.2, U4.11 (VSSA), U4.15 (VREFN), U4.31 (VSS), U4.41 (VSS), U4.55 (VSS), U4.72 (VSS), U4.83 (VSS), U4.97 (VSS), Y1.2, Y1.4; also elsewhere on the board
unnamed: C1.1, U4.22 (XTAL1), Y1.1
unnamed: C2.1, U4.23 (XTAL2), Y1.3 (case)
unnamed: D1.1 (K1), R8.1
unnamed: D1.3 (K2), R9.1
unnamed: Q1.1 (G), R7.2
unnamed: Q1.3 (D), R8.2
unnamed: Q2.1 (G), R11.2
unnamed: Q2.3 (D), R9.2
unnamed: R2.1, U4.4 (~TRST~)
V_JATG: P2.8

Notes on the sheet:
Master/Slave signal

Parts:
C32, C33, C34, C35, C36, C37: 100nF; C_0603
J10: PLB1G020002
J11: PLB1G020010
J12: PLB1G020004
P3, P5: CONN_01X03; Pin_Header_Straight_1x03
P4, P6: CONN_01X05; Pin_Header_Straight_1x05
R18, R19, R20, R21: 1k; R_0603
R22, R23, R24, R25: 560; R_0603
U9, U10: HCPL062N; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
/Analog Front End/BIAS_INV: J12.1, J12.3; also elsewhere on the board
/Analog Front End/CLK: J11.1; also elsewhere on the board
/Analog Front End/GPIO1: C36.1, R21.1, U9.6; also elsewhere on the board
/Analog Front End/GPIO2: C34.1, R20.1, U9.7; also elsewhere on the board
/Analog Front End/GPIO3: C37.1, R19.1, U10.6; also elsewhere on the board
/Analog Front End/GPIO4: C35.1, R18.1, U10.7; also elsewhere on the board
/Analog Front End/M/S: J11.6; also elsewhere on the board
/Analog Front End/MISO: J11.8, P6.3; also elsewhere on the board
/Analog Front End/MOSI: J11.7, P6.2; also elsewhere on the board
/Analog Front End/RESET/: J11.4; also elsewhere on the board
/Analog Front End/START: J11.3; also elsewhere on the board
/Interfaz Interconectividad/CS1: J11.2; also elsewhere on the board
/Interfaz Interconectividad/CS2: J11.5; also elsewhere on the board
/Interfaz Interconectividad/CS3: P6.5; also elsewhere on the board
/Interfaz Interconectividad/SCL: P3.2; also elsewhere on the board
/Interfaz Interconectividad/SDA: P3.1; also elsewhere on the board
/Microcontrolador/SCK: J11.9, P6.4; also elsewhere on the board
A_VCC: P5.1; also elsewhere on the board
D_VCC: C32.1, C33.1, P5.3, R18.2, R19.2, R20.2, R21.2, U9.8, U10.8; also elsewhere on the board
GND: C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, J11.10, P3.3, P5.2, P6.1, U9.5, U10.5; also elsewhere on the board
GNDA: J12.2, J12.4; also elsewhere on the board
GND_IN: P4.1, U9.2, U9.3, U10.2, U10.3
NI_GND: J10.2; also elsewhere on the board
unnamed: P4.2, R24.1
unnamed: P4.3, R25.1
unnamed: P4.4, R22.1
unnamed: P4.5, R23.1
unnamed: R22.2, U9.1
unnamed: R23.2, U9.4
unnamed: R24.2, U10.1
unnamed: R25.2, U10.4
V_USB_IO: J10.1; also elsewhere on the board

Notes on the sheet:
Conector alimentación propósito general
Bus SPI
Selección Módulo
Bus I2C
Conector Pines GPIO-ADS1299
Conectores SPI-I2C Propósito General
Tierra analógica
Conector para placa Slave (Bias_Inv y tierra analógica aislada)
Conector para placa Slave (Tierra y señales digitales, aisladas)
Conector para placa Slave (Alimentación no aislada)
NO AISLADO!
Tierra digital
BioAmp v1.1.0
Laboratorio de Prototipado Electronico y 3D - FIUNER

Parts:
C11, C16: 0.1uF; C_0603
C12, C17, C19: 10uF; C_0603
C13: 10nF; C_0603
C14, C15: 47pF; C_0603
C18, C22: 100nF; C_0603
C20: 4.7uF; c_tant_A
C21, C23: 1uF; C_0603
D2: D_Schottky; diode_0603
D4: LED; LED_0603
J13: USB_B; USB_B-smd
L1, L2, L3, L4: INDUCTOR_SMALL; FER-0805
NT1: Net_Tie; Net_tie
R13, R14: 27; R_0603
R15: 0R; R_0603
R16: 560; R_0603
U5: ADUM6201CRWZ; SOIC-16_7.5x10.3mm_Pitch1.27mm
U6: TPD2E001DRLR; 5-Flat_Leads_1.2x1.6mmPitch_0.5mm
U7: FT230XS; SSOP-16_3.9x4.9mm_Pitch0.635mm
VR1: LP5907_3.3V; sot23-5

Connections:
5V_ISO: C16.1, C17.1, C19.1, C21.1, L3.1, U5.10 (VE2), U5.11 (VSEL), U5.16 (VISO), VR1.1 (IN), VR1.3 (EN); also elsewhere on the board
5V_NI: C11.1, C12.1, D2.C, L4.1, U5.1 (VDD1), U5.6 (RCSEL), U5.7 (VE1)
/Comunicacion USB/3V3OUT: C22.1, U7.3 (VCCIO), U7.10 (3V3OUT), U7.11 (~RESET)
/Comunicacion USB/D_N: C14.1, J13.2 (D-), R13.2, U6.3 (IO1)
/Comunicacion USB/D_P: C15.1, J13.3 (D+), R14.2, U6.5 (IO2)
/Comunicacion USB/I_RX0: U5.14 (VOA); also elsewhere on the board
/Comunicacion USB/I_TX0: U5.13 (VIB); also elsewhere on the board
/Comunicacion USB/RX0: U5.3 (VIA), U7.1 (TXD)
/Comunicacion USB/TX0: U5.4 (VOA), U7.4 (RXD)
/Comunicacion USB/USBD+: R14.1, U7.8 (USBDP)
/Comunicacion USB/USBD-: R13.1, U7.9 (USBDM)
A_VCC: L3.2; also elsewhere on the board
D_VCC: C23.1, VR1.5 (OUT); also elsewhere on the board
GND: C23.2, NT1.2; also elsewhere on the board
GNDA: C16.2, C17.2, C19.2, C21.2, NT1.1, U5.9 (GNDISO), U5.15 (GNDISO), VR1.2 (GND); also elsewhere on the board
NI_GND: C11.2, C12.2, C13.2, C14.2, C15.2, C18.2, C20.2, C22.2, J13.4 (GND), L1.2, U5.2 (GND1), U5.5 (RCIN), U5.8 (GND1), U6.4 (GND), U7.5 (GND), U7.13 (GND); also elsewhere on the board
unnamed: C13.1, J13.1 (VCC), L2.2
unnamed: D4.1 (K), R16.1
unnamed: J13.5 (shield), L1.1
unnamed: R15.1, U7.2 (~RTS)
unnamed: R15.2, U7.6 (~CTS)
unnamed: R16.2, U7.14 (CBUS1)
V_USB: C18.1, C20.1, D2.A, D4.2 (A), L2.1, U6.1 (VCC), U7.12 (VCC)
V_USB_IO: L4.2; also elsewhere on the board

Notes on the sheet:
NO AISLADO!
NO AISLADO!
NO AISLADO!
Filtrado alimentación analógica
I/O alimentación No-Aislada

Parts:
C24, C28, C31: 1uF; C_0603
C25, C30: 0.1uF; C_0603
C26: 10uF; C_0603
C27: 100uF; C_1206
C29: 1nF; C_0603
JP1, JP2: JUMPER; R_0603
R17: 1M; R_0603
U8: ADS1299; LQFP-64_10x10mm_Pitch0.5mm

Connections:
/Analog Front End/BIAS_INV: U8.61 (BIASINV); also elsewhere on the board
/Analog Front End/CLK: U8.37 (CLK); also elsewhere on the board
/Analog Front End/DRDY/: U8.47 (~DRDY~); also elsewhere on the board
/Analog Front End/GPIO1: U8.42 (GPIO1); also elsewhere on the board
/Analog Front End/GPIO2: U8.44 (GPIO2); also elsewhere on the board
/Analog Front End/GPIO3: U8.45 (GPIO3); also elsewhere on the board
/Analog Front End/GPIO4: U8.46 (GPIO4); also elsewhere on the board
/Analog Front End/M/S: U8.52 (CLKSEL); also elsewhere on the board
/Analog Front End/MISO: U8.43 (DOUT); also elsewhere on the board
/Analog Front End/MOSI: U8.34 (DIN); also elsewhere on the board
/Analog Front End/RESET/: U8.36 (~RESET~); also elsewhere on the board
/Analog Front End/RL_DRV: C29.1, R17.1; also elsewhere on the board
/Analog Front End/SRB1: JP1.2, U8.17 (SRB1); also elsewhere on the board
/Analog Front End/SRB2: JP2.2, U8.18 (SRB2); also elsewhere on the board
/Analog Front End/START: U8.38 (START); also elsewhere on the board
/Entradas Analogicas/IN1+: U8.16 (IN1P); also elsewhere on the board
/Entradas Analogicas/IN1-: U8.15 (IN1N); also elsewhere on the board
/Entradas Analogicas/IN2+: U8.14 (IN2P); also elsewhere on the board
/Entradas Analogicas/IN2-: U8.13 (IN2N); also elsewhere on the board
/Entradas Analogicas/IN3+: U8.12 (IN3P); also elsewhere on the board
/Entradas Analogicas/IN3-: U8.11 (IN3N); also elsewhere on the board
/Entradas Analogicas/IN4+: U8.10 (IN4P); also elsewhere on the board
/Entradas Analogicas/IN4-: U8.9 (IN4N); also elsewhere on the board
/Entradas Analogicas/IN5+: U8.8 (IN5P); also elsewhere on the board
/Entradas Analogicas/IN5-: U8.7 (IN5N); also elsewhere on the board
/Entradas Analogicas/IN6+: U8.6 (IN6P); also elsewhere on the board
/Entradas Analogicas/IN6-: U8.5 (IN6N); also elsewhere on the board
/Entradas Analogicas/IN7+: U8.4 (IN7P); also elsewhere on the board
/Entradas Analogicas/IN7-: U8.3 (IN7N); also elsewhere on the board
/Entradas Analogicas/IN8+: U8.2 (IN8P); also elsewhere on the board
/Entradas Analogicas/IN8-: U8.1 (IN8N); also elsewhere on the board
/Interfaz Interconectividad/CS1: U8.39 (~CS~); also elsewhere on the board
/Microcontrolador/SCK: U8.40 (SCLK); also elsewhere on the board
A_VCC: U8.19 (AVDD), U8.21 (AVDD), U8.22 (AVDD), U8.54 (AVDD1), U8.56 (AVDD), U8.59 (AVDD); also elsewhere on the board
D_VCC: U8.35 (~PWDN~), U8.48 (DVDD), U8.50 (DVDD); also elsewhere on the board
GND: U8.31 (RESV1), U8.33 (DGND), U8.41 (DAISY_IN), U8.49 (DGND), U8.51 (DGND); also elsewhere on the board
GNDA: C24.2, C25.2, C26.2, C27.2, C28.2, C30.2, C31.2, U8.20 (AVSS), U8.23 (AVSS), U8.25 (VREFN), U8.32 (AVSS), U8.53 (AVSS1), U8.57 (AVSS), U8.58 (AVSS), U8.60 (BIASREF); also elsewhere on the board
unnamed: C24.1, U8.26 (VCAP4)
unnamed: C25.1, C26.1, U8.24 (VREFP)
unnamed: C27.1, U8.28 (VCAP1)
unnamed: C28.1, U8.30 (VCAP2)
unnamed: C29.2, R17.2, U8.62 (BIASIN), U8.63 (BIASOUT)
unnamed: C30.1, C31.1, U8.55 (VCAP3)
unnamed: JP1.1, JP2.1

Notes on the sheet:
CLK interno
Salida señal de CLK para placa "slave"
Señales de referencia
Siempre encendido (si hay alimentación)
Referencia interna 4.5V
CLKSEL debe conectarse a VCC en caso de ser MASTER y a GND en caso de ser SLAVE. Se puede conectar a la misma linea de control M/S.

Parts:
J14, J17: PXG.M0.2GG.NG
J15, J18: PXG.M0.4GG.NG
J16, J19: PXG.M1.0GG.NG

Connections:
unnamed: J14.1, J17.1
unnamed: J14.2, J17.2
unnamed: J15.1, J15.3, J18.1, J18.3
unnamed: J15.2, J15.4, J18.2, J18.4
unnamed: J16.1, J19.1
unnamed: J16.2, J19.5
unnamed: J16.3, J19.3
unnamed: J16.4, J19.4
unnamed: J16.5, J19.2
unnamed: J16.7, J19.7
unnamed: J16.8, J19.8
unnamed: J16.9, J19.9
unnamed: J16.10, J19.6, J19.10

Notes on the sheet:
Plug de 2 posiciones
Plug de 4 posiciones
Plug de 10 posiciones
CLK
CS1
START
RESET/
CS2
M/S
MOSI
MISO
SCLK
GND
CS1
BIAS_INV
V_USB_IO
NI_GND

Board: 2 copper layers, 120.0 x 98.0 mm, 116 parts (0 on the bottom side), 103 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_3-5mm
SRB1, SRB2: JUMPER; R_0603

Their connections:
/Analog Front End/SRB1: SRB1.2; also elsewhere on the board
/Analog Front End/SRB2: SRB2.2; also elsewhere on the board
/Entradas Analogicas/IN_SRB: SRB1.1, SRB2.1; also elsewhere on the board

## KiCad design Hardware/BioAmp_v1.1.0_DB/BioAmp_v1.1.0_DB.kicad_pcb

Board: 2 copper layers, 120.0 x 33.0 mm, 23 parts (0 on the bottom side), 19 nets.

Parts:
CN1, CN2, CN3: CKCL44X7R1H; Cap_Array_4
J2, J3, J4, J5, J6, J7, J8, J9, J10: Jack_Touch-Proof; Jack_TouchProof_1.5mm
MH1, MH2, MH3, MH4: MountingHole_3-5mm
P1: CONN_01X10; Pin_Header_Straight_1x10
RN1, RN2, RN3: CAY16-F4_R-ARRAY; r_cay16-4
U1, U2, U3: TPD4E1B06; TSOP-6_2x1.25mm_Pitch0.65mm

Connections:
/IN3+: J9.1, RN2.4, U2.5
/IN3-: J8.1, RN2.3, U2.4
/IN4+: J7.1, RN2.2, U2.2
/IN4-: J6.1, RN2.1, U2.1
/IN5+: J5.1, RN1.4, U1.5
/IN5-: J4.1, RN1.3, U1.4
/IN6+: J3.1, RN1.2, U1.2
/IN6-: J2.1, RN1.1, U1.1
/RL_DRV: J10.1, RN3.1, U3.1
GNDA: CN1.5, CN1.6, CN1.7, CN1.8, CN2.5, CN2.6, CN2.7, CN2.8, CN3.5, CN3.6, CN3.7, CN3.8, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, P1.10, U1.3, U2.3, U3.3
unnamed: CN1.1, P1.6, RN1.5
unnamed: CN1.2, P1.7, RN1.6
unnamed: CN1.3, P1.8, RN1.7
unnamed: CN1.4, P1.9, RN1.8
unnamed: CN2.1, P1.2, RN2.5
unnamed: CN2.2, P1.3, RN2.6
unnamed: CN2.3, P1.4, RN2.7
unnamed: CN2.4, P1.5, RN2.8
unnamed: CN3.1, P1.1, RN3.8
